# Keil uVision project RCT6_Project.uvprojx, settings and files
target RCT6 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: IPMC_NT +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: ..\user;..\platform;..\platform\inc;..\driver\FWLib\inc;..\driver\CMSIS;..\CM3_driver;..\ipmi;..\soft_timer
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ../user/: main.c
  group FWLib
    ../driver/FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group CMSIS
    ../driver/CMSIS/: core_cm3.c system_stm32f10x.c
  group Startup
    ../driver/: startup_stm32f10x_hd.s
  group Platform
    ../platform/: platform_IT.c
    ../platform/src/: gpio.c uart.c i2c.c adc.c
  group CM3_Driver
    ../CM3_driver/: cm3_driver.c
  group IPMI
    ../ipmi/: ipmi.c ipmi_event.c ipmi_protocol.c ipmi_sdr.c
  group SoftTimer
    ../soft_timer/: soft_timer.c
